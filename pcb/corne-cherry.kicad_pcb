# Repository gravitygo/corne-cherry

## KiCad design pcb/corne-cherry.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42: D; D3_SMD_v2
J1, J3: MJ-4PP-9; MJ-4PP-9_1side
J2, J4: OLED; OLED_1side
J5, J6: BAT; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
LED1, LED2, LED3, LED4, LED5, LED6, LED28, LED29, LED30, LED31, LED32, LED33: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54: YS-SK6812MINI-E
PSW1, PSW2: SW_SPDT; switch_SSSS811101
RSW1, RSW2: SW_PUSH; ResetSW_1side
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41: SW_PUSH; CherryMX_Hotswap
SW21, SW42: SW_PUSH; CherryMX_Hotswap_1.5u
U1, U2: ProMicro; ProMicro_v3

Connections:
GND: J1.C, J2.4, J5.2, J6.2, LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), LED7.3 (VSS), LED8.3 (VSS), LED9.3 (VSS), LED10.3 (VSS), LED11.3 (VSS), LED12.3 (VSS), LED13.3 (VSS), LED14.3 (VSS), LED15.3 (VSS), LED16.3 (VSS), LED17.3 (VSS), LED18.3 (VSS), LED19.3 (VSS), LED20.3 (VSS), LED21.3 (VSS), LED22.3 (VSS), LED23.3 (VSS), LED24.3 (VSS), LED25.3 (VSS), LED26.3 (VSS), LED27.3 (VSS), RSW1.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
GNDA: J3.C, J4.4, LED28.3 (VSS), LED29.3 (VSS), LED30.3 (VSS), LED31.3 (VSS), LED32.3 (VSS), LED33.3 (VSS), LED34.3 (VSS), LED35.3 (VSS), LED36.3 (VSS), LED37.3 (VSS), LED38.3 (VSS), LED39.3 (VSS), LED40.3 (VSS), LED41.3 (VSS), LED42.3 (VSS), LED43.3 (VSS), LED44.3 (VSS), LED45.3 (VSS), LED46.3 (VSS), LED47.3 (VSS), LED48.3 (VSS), LED49.3 (VSS), LED50.3 (VSS), LED51.3 (VSS), LED52.3 (VSS), LED53.3 (VSS), LED54.3 (VSS), RSW2.2, U2.3 (GND), U2.4 (GND), U2.23 (GND)
LED: LED3.4 (DIN), U1.1 (TX0/D3)
LED_r: LED30.4 (DIN), U2.1 (TX0/D3)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: J5.1, PSW1.2 (B)
unnamed: J6.1, PSW2.2 (B)
unnamed: LED1.2 (DOUT), LED4.4 (DIN)
unnamed: LED1.4 (DIN), LED2.2 (DOUT)
unnamed: LED2.4 (DIN), LED3.2 (DOUT)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED7.4 (DIN), LED8.2 (DOUT)
unnamed: LED9.4 (DIN), LED10.2 (DOUT)
unnamed: LED10.4 (DIN), LED16.2 (DOUT)
unnamed: LED11.2 (DOUT), LED17.4 (DIN)
unnamed: LED11.4 (DIN), LED12.2 (DOUT)
unnamed: LED12.4 (DIN), LED18.2 (DOUT)
unnamed: LED13.2 (DOUT), LED19.4 (DIN)
unnamed: LED7.2 (DOUT), LED13.4 (DIN)
unnamed: LED8.4 (DIN), LED14.2 (DOUT)
unnamed: LED14.4 (DIN), LED20.2 (DOUT)
unnamed: LED15.2 (DOUT), LED21.4 (DIN)
unnamed: LED9.2 (DOUT), LED15.4 (DIN)
unnamed: LED16.4 (DIN), LED22.2 (DOUT)
unnamed: LED17.2 (DOUT), LED23.4 (DIN)
unnamed: LED18.4 (DIN), LED24.2 (DOUT)
unnamed: LED20.4 (DIN), LED21.2 (DOUT)
unnamed: LED22.4 (DIN), LED25.2 (DOUT)
unnamed: LED23.2 (DOUT), LED26.4 (DIN)
unnamed: LED24.4 (DIN), LED27.2 (DOUT)
unnamed: LED25.4 (DIN), LED26.2 (DOUT)
unnamed: LED6.2 (DOUT), LED27.4 (DIN)
unnamed: LED28.2 (DOUT), LED31.4 (DIN)
unnamed: LED28.4 (DIN), LED29.2 (DOUT)
unnamed: LED29.4 (DIN), LED30.2 (DOUT)
unnamed: LED31.2 (DOUT), LED32.4 (DIN)
unnamed: LED32.2 (DOUT), LED33.4 (DIN)
unnamed: LED33.2 (DOUT), LED54.4 (DIN)
unnamed: LED34.2 (DOUT), LED40.4 (DIN)
unnamed: LED34.4 (DIN), LED35.2 (DOUT)
unnamed: LED35.4 (DIN), LED41.2 (DOUT)
unnamed: LED36.2 (DOUT), LED42.4 (DIN)
unnamed: LED36.4 (DIN), LED37.2 (DOUT)
unnamed: LED37.4 (DIN), LED43.2 (DOUT)
unnamed: LED38.2 (DOUT), LED44.4 (DIN)
unnamed: LED38.4 (DIN), LED39.2 (DOUT)
unnamed: LED39.4 (DIN), LED45.2 (DOUT)
unnamed: LED40.2 (DOUT), LED46.4 (DIN)
unnamed: LED41.4 (DIN), LED47.2 (DOUT)
unnamed: LED42.2 (DOUT), LED48.4 (DIN)
unnamed: LED43.4 (DIN), LED49.2 (DOUT)
unnamed: LED44.2 (DOUT), LED50.4 (DIN)
unnamed: LED45.4 (DIN), LED51.2 (DOUT)
unnamed: LED47.4 (DIN), LED48.2 (DOUT)
unnamed: LED49.4 (DIN), LED52.2 (DOUT)
unnamed: LED50.2 (DOUT), LED53.4 (DIN)
unnamed: LED51.4 (DIN), LED54.2 (DOUT)
unnamed: LED52.4 (DIN), LED53.2 (DOUT)
RAW: PSW1.1 (A), U1.24 (RAW)
RAW_r: PSW2.1 (A), U2.24 (RAW)
SCL: J2.2, U1.6 (3/D0/SCL)
SCL_r: J4.2, U2.6 (3/D0/SCL)
SDA: J2.1, U1.5 (2/D1/SDA)
SDA_r: J4.1, U2.5 (2/D1/SDA)
VCC: J1.D, J2.3, LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), LED20.1 (VDD), LED21.1 (VDD), LED22.1 (VDD), LED23.1 (VDD), LED24.1 (VDD), LED25.1 (VDD), LED26.1 (VDD), LED27.1 (VDD), U1.21 (VCC)
VDD: J3.D, J4.3, LED28.1 (VDD), LED29.1 (VDD), LED30.1 (VDD), LED31.1 (VDD), LED32.1 (VDD), LED33.1 (VDD), LED34.1 (VDD), LED35.1 (VDD), LED36.1 (VDD), LED37.1 (VDD), LED38.1 (VDD), LED39.1 (VDD), LED40.1 (VDD), LED41.1 (VDD), LED42.1 (VDD), LED43.1 (VDD), LED44.1 (VDD), LED45.1 (VDD), LED46.1 (VDD), LED47.1 (VDD), LED48.1 (VDD), LED49.1 (VDD), LED50.1 (VDD), LED51.1 (VDD), LED52.1 (VDD), LED53.1 (VDD), LED54.1 (VDD), U2.21 (VCC)
col0: SW1.1, SW7.1, SW13.1, U1.20 (F4/A3)
col0_r: SW22.1, SW28.1, SW34.1, U2.20 (F4/A3)
col1: SW2.1, SW8.1, SW14.1, U1.19 (F5/A2)
col1_r: SW23.1, SW29.1, SW35.1, U2.19 (F5/A2)
col2: SW3.1, SW9.1, SW15.1, U1.18 (F6/A1)
col2_r: SW24.1, SW30.1, SW36.1, U2.18 (F6/A1)
col3: SW4.1, SW10.1, SW16.1, SW19.1, U1.17 (F7/A0)
col3_r: SW25.1, SW31.1, SW37.1, SW40.1, U2.17 (F7/A0)
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16 (B1/15)
col4_r: SW26.1, SW32.1, SW38.1, SW41.1, U2.16 (B1/15)
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15 (B3/14)
col5_r: SW27.1, SW33.1, SW39.1, SW42.1, U2.15 (B3/14)
data: J1.B, U1.2 (RX1/D2)
data_r: J3.B, U2.2 (RX1/D2)
reset: RSW1.1, U1.22 (RST)
reset_r: RSW2.1, U2.22 (RST)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.7 (4/D4)
row0_r: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), U2.7 (4/D4)
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.8 (5/C6)
row1_r: D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), U2.8 (5/C6)
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.9 (6/D7)
row2_r: D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), U2.9 (6/D7)
row3: D19.1 (K), D20.1 (K), D21.1 (K), U1.10 (7/E6)
row3_r: D40.1 (K), D41.1 (K), D42.1 (K), U2.10 (7/E6)

Board: 2 copper layers, 275.5 x 105.6 mm, 162 parts (101 on the bottom side), 130 nets.

Other parts of the board:
Ref**: Val**; M2_HOLE_v2
Ref**#2, Ref**#3, Ref**#4, Ref**#5, Ref**#6, Ref**#7, Ref**#8, Ref**#9, Ref**#10, Ref**#11, Ref**#12, Ref**#13, Ref**#14: Val**; M2_HOLE_v2

## Commit log

2024-09-23 Corne Update
